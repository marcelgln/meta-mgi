# Updated boot script which uses FAT partition 7 instead of 1 for the kernel. 

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"



